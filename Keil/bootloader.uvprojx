# Keil uVision project bootloader.uvprojx, settings and files
target lpc11xx (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: LPC1114FBD48/301 NXP
  pack: Keil.LPC1100_DFP.1.4.0
  cpu: IRAM(0x10000000,0x2000) IROM(0x00000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: bootloader +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: LPC1XXX,FLASH_32
  c include: ..\..\lpc11xx_bootloader;..\Core\Device\NXP\LPC11xx\Include;..\Core\CMSIS\Include;..\drivers\inc;..\iap\inc;..\main
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  group Startup
    ../Core/Device/NXP/LPC11xx/Source/Templates/startup/arm/: startup_LPC11xx.s
  group CMSIS_CM0
    ../Core/Device/NXP/LPC11xx/Source/Templates/: system_LPC11xx.c
  group IAP
    ../iap/src/: FlashDev.c FlashPrg.c
  group Driver
    ../drivers/src/: LPC11xx_uart.c LPC11xx_debug.c
  group Main
    ../main/: bootloder.c
