LR_IROM1 0x00000000 0x00001000 {
	ER_IROM1 0x00000000 0x00001000 {
		*.o (RESET, +First)
		*(InRoot$$Sections)
		.ANY (+RO)
	}
	RW_IRAM1 0x10000000 0x10002000 {
		* (+RO, +RW, +ZI)
	}
}